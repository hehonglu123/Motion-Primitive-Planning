Commit message: fwd eef

File: simulation/gazebo_sim/toolbox/6640.urdf (robot description, URDF)
Before this commit: robot abb_irb6640_180_255, 10 links, 9 joints
Joints:
- joint joint_5: origin xyz=1.142 0 0  rpy=0 0 0 -> xyz=1.1425 0 0  rpy=0 0 0
